# Keil uVision project idea-app.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MAX32555 Maxim Integrated
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x10000020-0x1007FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3") ELITTLE
  output: idea-app
  AfterMake: fromelf.exe --bin -o ./scp_packets.bin ./Objects/idea-app.axf
  AfterMake: casign.bat
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --gnu
  c include: ..\..\source;..\..\..\board;..\..\..\..\..\qs;..\..\..\..\..\qs\modules;..\..\..\..\..\qs\modules\device;..\..\..\..\..\qs\modules\lib\utility;..\..\..\..\..\qs\modules\lib\json;..\..\..\..\..\qs\modules\lib\base64;..\..\..\..\..\qs\modules\lib\algo;..\..\..\..\..\platform\max32555;..\..\..\..\..\platform\max32555\sdk\include;..\..\..\..\..\platform\max32555\sdk\include\ucl;..\..\..\..\..\platform\max32555\sdk\drivers\common;..\..\..\..\..\platform\max32555\sdk\drivers\max3255X\include;..\..\..\..\..\platform\max32555\sdk\drivers\max3255X\include\arch;..\..\..\..\..\platform\max32555\sdk\drivers\max3255X\include\dev;..\..\..\..\..\platform\max32555\sdk\drivers\max3255X\include\usb\core;..\..\..\..\..\platform\max32555\sdk\drivers\max3255X\include\usb\core\arm;..\..\..\..\..\platform\max32555\sdk\drivers\max3255X\include\usb\devclass;..\..\..\..\..\platform\max32555\sdk\drivers\max3255X\include\usb\enumerate;..\..\..\..\..\platform\win32\ae;..\..\..\..\..\qs\system;..\..\..\..\..\qs\system\senv
  memory RVCT4: ROM 0x10000020 size 0x7ffe0
  memory RVCT9: RAM 0x20000000 size 0x18000
  group app
    ../../source/: qs_cfg.h idea_coder.h idea_player.h idea_pwd.h idea_comm.h app.c app.h ga_conf.h idea_app.c idea_app.h idea_cmd.c idea_cmd.h idea_qs.c idea_qs.h main.c
    ../../source/Control/: CMD_Fish.c CommonStruct.c ComputerData.c Dll.c NatureAlg.c GameConfig.c GameManager.c Lottery.c LotteryManager.c CMD_Fish.h CommonStruct.h ComputerData.h DllInterface.h GameConfig.h GameManager.h Lottery.h LotteryManager.h NatureAlg.h Test.h GameRegistry.c RtpConfig.c TableControl.c
    ../../source/Control/GenerationResult/: GameResult_1700.c GameResult_3998.c GameResult_3999.c GameResultRegistry.c GameResult_3993.c GameResult_3995.c GameResult_3996.c GameResult_3997.c
    ../../source/Control/Matrix/: Matrix_u_TriggersById.c MatrixApplyTriggers_1700.c MatrixApplyTriggers_3998.c MatrixApplyTriggers_3999.c MatrixApplyTriggers_3993.c MatrixApplyTriggers_3995.c MatrixApplyTriggers_3996.c MatrixApplyTriggers_3997.c
  group board
    ../../../board/: driver_led.h qs_board.h driver_flash.h driver_fram.h startup_max3255X.s
  group platform
    ../../../../../platform/max32555/: descriptors.h driver_iflash.h driver_nvram.h driver_serial.h driver_timer.h driver_usb.h qs_platform.h
    ../../../../../platform/win32/ae/: qs_ae_aes.h qs_ae_algo.h qs_ae_des.h qs_ae_rand.h qs_ae_sha.h
  group qs
    ../../../../../qs/: qs.h qs_driver.h qs_task.h
    ../../../../../qs/modules/: qs_modules.h
    ../../../../../qs/modules/device/: qs_buzzer.h qs_keyboard.h qs_led.h qs_mm.h qs_database.h
    ../../../../../qs/modules/lib/algo/: qs_aes.h qs_aes_cbc.h qs_aes_ecb.h qs_algo.h qs_crc16.h qs_des.h qs_des_cbc.h qs_des_ecb.h qs_nn.h qs_prime.h qs_rand.h qs_rsa.h qs_sha1.h qs_sha224.h qs_sha256.h qs_sha384.h qs_sha512.h
    ../../../../../qs/modules/lib/base64/: qs_base64.h
    ../../../../../qs/modules/lib/json/: qs_json.h
    ../../../../../qs/modules/lib/utility/: qs_fifo.h qs_list.h qs_log.h qs_mem.h qs_utility.h
    ../../../../../qs/system/senv/: qs_senv.h qs_senv_manager.h
  group sdk
    ../../lib/: ideabase.lib
    ../../../../../platform/max32555/sdk/lib/: libucl-2.4.7_max32555.lib
    ../../../../../platform/max32555/sdk/drivers/build/: libmml.lib
  group ga
    ../../source/GameAlgo/algo/: ga.c ga.h
    ../../source/GameAlgo/cJSON/: cJSON.c cJSON.h cJSON_Utils.c cJSON_Utils.h
    ../../source/GameAlgo/common/: JRand.c JRand.h SFMT.c SFMT.h SFMT-common.h SFMT-params.h SFMT-params19937.h
